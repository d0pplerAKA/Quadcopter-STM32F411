# Keil uVision project quadcopter_Fly_by_Wire_stm32f411ceu6.uvprojx, settings and files
target proj (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: quadcopter_Fly_by_Wire_stm32f411ceu6
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1,__CC_ARM,ARM_MATH_ROUNDING
  c include: ..\quadcopter_Fly_by_Wire_stm32f411ceu6;.\CMSIS\STARTUP;.\CMSIS;.\FWLIB\src;.\FWLIB\inc;.\Header;.\Header\vl53l1x\core;.\Header\vl53l1x\platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx_it.c system_stm32f4xx.c arm_math.h arm_cortexM4lf_math.lib arm_common_tables.h arm_const_structs.h
    ./CMSIS/STARTUP/: startup_stm32f411xe.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Header
    ./Header/delay/: delay.c
    ./Header/gy_95t/: gy_95t.c
    ./Header/led/: led.c
    ./Header/timer/: timer.c
    ./Header/uart/: uart1.c uart2.c
    ./Header/bl_motor/: bl_motor.c
    ./Header/ms5611/: ms5611.c
    ./Header/nrf24l01p/: nrf24l01p.c nrf24l01p_tools.c
    ./Header/spi/: spi1.c
    ./Header/xbox/: xbox.c
    ./Header/i2c/: i2c.c i2c1.c i2c2.c i2c3.c
    ./Header/adc_voltage/: adc_voltage.c
    ./Header/tof400c/: tof400c.c
    ./Header/post/: post.c
    ./Header/fwb_stm32f4/: fwb.c
    ./Header/flash_stm32f4/: flash.c
    ./Header/gl9306/: gl9306.c
  group User
    ./: main.c stm32f4xx.h stm32f4xx_conf.h
  group VL53L1X
    ./Header/vl53l1x/platform/: vl53l1_platform.c
    ./Header/vl53l1x/core/: VL53L1X_api.c VL53L1X_calibration.c
